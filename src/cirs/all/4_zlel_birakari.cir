B1   1 0 0 0  5 1e3 90		0
J1   1 0 2 0  0.5e-3 0 0	0
R1   2 0 0 0  1e3 0 0		0
.pr  0 0 0 0  0 0 0		0
.op  0 0 0 0  0 0 0		0
.tr  0 0 0 0  0 2e-3 1e-5	0
